# Keil uVision project exp_5.uvproj, settings and files
target Timer (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: exp_5 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\common\CMSIS;..\common\Config;..\common\Lib\inc;.\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../common/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../common/CMSIS/: system_stm32f10x.c
  group Lib
    ../common/Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../common/Config/: led.c time.c
    ./user/: main.c stm32f10x_it.c
