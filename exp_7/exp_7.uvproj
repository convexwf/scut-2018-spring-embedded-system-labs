# Keil uVision project exp_7.uvproj, settings and files
target control (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: exp_7 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\common\CMSIS;..\common\Lib\inc;.\user;.\ucosii\config;.\ucosii\core;.\ucosii\port
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../common/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../common/CMSIS/: system_stm32f10x.c
  group Lib
    ../common/Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
  group ucos-II_config
    ./ucosii/config/: includes.h os_cfg.h
  group ucos-II_core
    ./ucosii/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-II_port
    ./ucosii/port/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group User
    ./user/: main.c stm32f10x_it.c usart.c led.c adc.c
